#pragma once
#include "RoasterUIWidgets.h"
#include "RoasterUINav.h"
#include "RoasterUIBridge.h"
#include "RoasterAlarmSound.h"   // g_alarm_sound (preview chirp while adjusting volume)

struct UiMainState {
    UiShell   shell        = {};
    lv_obj_t *imgModeIco   = nullptr;
    lv_obj_t *lblModeSub   = nullptr;
    UiToneBtn btnMode      = {};
    UiToneBtn btnSetting   = {};
    int       lastLinkMode = -1;
    char      lastTopMid[24]= "";

    // Setting (4 large icons, no sub text)
    UiToneBtn btnSystem    = {};
    UiToneBtn btnLang      = {};
    lv_obj_t *lblLangCut   = nullptr;

    // System (Overheat level, IDLE time and screen brightness)
    lv_obj_t *lblSysHot    = nullptr;
    lv_obj_t *lblSysIdle   = nullptr;
    lv_obj_t *lblSysBl     = nullptr;
    lv_obj_t *lblSysBlTit  = nullptr;
    UiToneBtn btnSysUnitC  = {};
    UiToneBtn btnSysUnitF  = {};
    // System: Sound card (Mute + volume slider + % value)
    UiToneBtn btnSysMute   = {};
    lv_obj_t *lblSysMute   = nullptr;
    lv_obj_t *sldSysVol    = nullptr;
    lv_obj_t *lblSysVol    = nullptr;

    // Wifi (IP Card + iOS Switch AP/WIFI)
    lv_obj_t *lblIpBig     = nullptr;
    lv_obj_t *swWifiMode   = nullptr;
    lv_obj_t *lblAp        = nullptr;
    lv_obj_t *lblSta       = nullptr;

    // PID Parameter editor (Kp | Ki | Kd + P-Mode)
    UiPidParams editP      = {};
    uint8_t   activeCol    = 0;        // 0=Kp, 1=Ki, 2=Kd, 3=P-Mode
    lv_obj_t *colCard[3]   = {nullptr, nullptr, nullptr};
    lv_obj_t *colVal[3]    = {nullptr, nullptr, nullptr};
    lv_obj_t *pmCard       = nullptr;
    lv_obj_t *pmVal        = nullptr;
};

static UiMainState g_uiMain;

static inline void uiSyncMainBattery() {
    uiUpdateTopRight(g_uiMain.shell, g_uiSnap.batPct, g_uiSnap.batCharging);
    uiUpdateTopClock(g_uiMain.shell, g_uiSnap.clockSynced, g_uiSnap.clockStr);
}

static inline const char* uiLangCode(UiLang l) {
    switch (l) {
        case UILANG_VI: return "VI";
        case UILANG_EN: return "EN";
        case UILANG_CN: return "CN";
        default:        return "VI";
    }
}

static inline UiLang uiNextEnabledLang(UiLang cur) {
    const UiLang order[3] = {UILANG_VI, UILANG_EN, UILANG_CN};
    int curIdx = 0;
    for (int i = 0; i < 3; ++i) {
        if (order[i] == cur) { curIdx = i; break; }
    }
    for (int step = 1; step <= 3; ++step) {
        UiLang cand = order[(curIdx + step) % 3];
        if (uiLangEnabled(cand)) return cand;
    }
    return cur;
}

// ---------------- HOME ----------------
// Flat START button (same fill / border as the bottom buttons): round orange badge with a flame cut-out + "START" (white)
// + "ROAST" (orange). Style 7: top line START (22 px, letter-spaced) + white play triangle 17x19, bottom line ROAST 31 px orange; pre-drawn as a sharp A8 image, both lines edge-aligned.
#define UI_START_H          108    // START button height; 108 + 5 + 89 (bottom row) = 202 (inner H)
#define UI_START_BADGE_X    20     // distance from the button's left edge
#define UI_START_ROAST_R    207    // right edge (exclusive) of ROAST text and the play triangle; ROAST 110% fixed to the bottom right
#define UI_START_ROAST_BASE 80     // ROAST text baseline (button content coordinates)
#define UI_START_LINE1_BASE 47     // START text baseline
#define UI_START_TRI_Y      29     // top of the 17x19 play triangle (vertical center ~ START text center)
// The three HOME buttons span the full 240 px width (offset -UI_MARGIN to the edge): START 240 | Mode 117 (extends left) + 5 px + Setting 118 (extends right)
#define UI_HOME_W           UI_SCR_W
#define UI_HOME_COL_L       ((UI_SCR_W - UI_GAP) / 2)
#define UI_HOME_COL_R       (UI_SCR_W - UI_GAP - UI_HOME_COL_L)
// Setting and its sub pages (Setting, System, WiFi, PID, Parameter) also span the full 240 px: body side margins removed (uiBodyFullWidth)
#define UI_FULL_COL2_W      ((UI_SCR_W - UI_GAP) / 2)                                       // 117
#define UI_FULL_COL2_W_R    (UI_SCR_W - UI_GAP - UI_FULL_COL2_W)                            // 118
#define UI_FULL_COL3_W      ((UI_SCR_W - UI_GAP * 2) / 3)                                   // 76
#define UI_FULL_COL3_W_M    ((UI_SCR_W - UI_GAP * 2 - UI_FULL_COL3_W) / 2)                  // 77
#define UI_FULL_COL3_W_R    (UI_SCR_W - UI_GAP * 2 - UI_FULL_COL3_W - UI_FULL_COL3_W_M)     // 77
static inline void uiBodyFullWidth(UiShell &sh) { lv_obj_set_style_pad_hor(sh.body, 0, LV_PART_MAIN); }
static const uint8_t ui_ico_start_flame_map[68 * 68] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
    0x00, 0x06, 0x32, 0x64, 0x95, 0xBE, 0xD8, 0xE8, 0xFD, 0xFF, 0xFF, 0xFD, 0xE8, 0xD8, 0xBE, 0x95, 0x64, 0x32, 0x06, 0x00, 0x00, 0x00, 0x03, 0x03,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x12, 0x56, 0x9F, 0xD8, 0xFB, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xD8, 0x9F, 0x56, 0x12, 0x00, 0x00, 0x01, 0x03, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x38, 0x9C, 0xE9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFD, 0xFE, 0xFE,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFD, 0xFC, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE9, 0x9C, 0x38, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x01, 0x04, 0x00, 0x00, 0x45, 0xBA, 0xFF, 0xFF, 0xFF, 0xFC, 0xFB, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xFC, 0xFF, 0xFF, 0xFF, 0xBA, 0x45, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
    0x30, 0xB1, 0xFF, 0xFF, 0xFE, 0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xFE, 0xFF, 0xFF, 0xB1, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x05, 0x80, 0xF8, 0xFF, 0xFD, 0xFC,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFD, 0xFF, 0xF8, 0x80, 0x05, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x2A, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0x2A, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x56, 0xF0, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
    0xFB, 0xFF, 0xF0, 0x56, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x01, 0x03, 0x00, 0x78, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
    0x78, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0x00, 0x8D, 0xFF,
    0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xFF, 0x8D, 0x00, 0x03,
    0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x8D, 0xFF, 0xFA, 0xFE, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF5, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFA, 0xFF, 0x8D, 0x00, 0x04, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x77, 0xFF, 0xFA, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xD7, 0xB1, 0xFC, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFA, 0xFF, 0x77, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x54, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF3, 0x4B, 0x6B, 0xFD, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xFF, 0x54, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x02, 0x00, 0x26, 0xF4, 0xFD, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFC, 0xFF, 0x91, 0x00, 0x6D, 0xF8, 0xFD, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFD, 0xF4, 0x26, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0x04, 0xCC, 0xFF,
    0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xB6,
    0x07, 0x00, 0x74, 0xFA, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xCC, 0x04, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xB5, 0x07, 0x04, 0x03, 0x88,
    0xFC, 0xFA, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFB, 0xFF, 0x7F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x2A, 0xFB, 0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xAB, 0x02, 0x04, 0x01, 0x0E, 0xB7, 0xFF, 0xFC, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xFB, 0x2A,
    0x01, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xB6, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x73, 0x00, 0x04, 0x04, 0x00, 0x3F, 0xF1, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xB6, 0x00, 0x03, 0x00, 0x00,
    0x00, 0x03, 0x00, 0x40, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF2, 0x3D, 0x00, 0x04, 0x00, 0x02, 0x01, 0xA4, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x40, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0xBE,
    0xFE, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFD, 0xFF, 0xAF, 0x07, 0x01, 0x01, 0x00, 0x03, 0x00, 0x43, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0xBE, 0x00, 0x02, 0x00, 0x03, 0x00, 0x32, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xF2, 0x3C, 0x00,
    0x02, 0x00, 0x00, 0x00, 0x00, 0x0B, 0xCC, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x32, 0x00, 0x03, 0x03, 0x00, 0x9E, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x8D, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x01, 0xA2, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x9E, 0x00, 0x03, 0x00, 0x10, 0xED, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xC0, 0x15, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x77, 0xFF,
    0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
    0xFF, 0xED, 0x10, 0x00, 0x00, 0x55, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xDB, 0x2F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x5E, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x55, 0x00,
    0x00, 0xA0, 0xFE, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFD, 0xFF, 0xF5, 0x4C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x59, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0xA0, 0x00, 0x05, 0xDB, 0xFF, 0xFD,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFD, 0xF8, 0x6A, 0x00,
    0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x64, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xDB, 0x05, 0x30, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xFB, 0x76, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x70, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0x30, 0x65, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xFF, 0x92, 0x03, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x01, 0x00, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x65, 0x95, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xB0, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xB0, 0xFF,
    0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFC, 0xFF, 0x95, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFD, 0xFF, 0xCA, 0x1A, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x15, 0xD5, 0xFD, 0xFD, 0xFE, 0xFF, 0xED,
    0xB9, 0xF0, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF,
    0xDA, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xE3, 0x2F, 0x00,
    0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x41, 0xF6, 0xF9, 0xFE, 0xFE, 0xFD, 0xF6, 0x42, 0x8B, 0xFF, 0xFC,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDA, 0xEA, 0xFF, 0xFE, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFD, 0xFB, 0x58, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x86, 0xFF, 0xFC, 0xFF, 0xFE, 0xFD, 0xFF, 0x45, 0x0C, 0xCE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEA, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x9D, 0x03, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x01, 0x02, 0x00, 0xB0, 0xFF, 0xFD, 0xFF, 0xFE, 0xFD, 0xFC, 0x4B, 0x00, 0x44, 0xF5, 0xFD, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xDA, 0x1E, 0x01, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02,
    0x00, 0xAD, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0xF6, 0x3C, 0x01, 0x02, 0x92, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFE, 0xF8, 0x62, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x8C, 0xFF, 0xFA,
    0xFB, 0xFA, 0xFF, 0xCC, 0x15, 0x00, 0x00, 0x23, 0xE4, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0x05,
    0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3A, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0x73,
    0x00, 0x03, 0x04, 0x00, 0x88, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
    0xEA, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFD, 0x61, 0x00, 0x03, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x55, 0xDC, 0xF3, 0xEB, 0x8B, 0x0A, 0x00, 0x01, 0x02, 0x00,
    0x29, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEA, 0xDA, 0xFF, 0xFE, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xD8, 0x17, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x19, 0x48, 0x33, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xB4, 0xFF, 0xFE,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDA, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xA0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x02, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x71, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0x95, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x69, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x02, 0x04, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3A, 0xF5, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x95, 0x65, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xEF, 0x3B, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x19, 0xDC, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFC, 0xFF, 0x65, 0x30, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x26, 0x00, 0x03,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x0E, 0x36, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x01, 0x00, 0x13, 0xD1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0x30,
    0x05, 0xDB, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xD7, 0x21, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x01, 0x02, 0x00, 0x94, 0x99, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
    0x00, 0x0F, 0xC2, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xDB, 0x05, 0x00, 0xA0, 0xFE, 0xFB,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xD7, 0x21, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x02, 0x00, 0x4A, 0xFF, 0xB0, 0x08, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x10, 0xC2, 0xFF,
    0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0xA0, 0x00, 0x00, 0x55, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x29, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x18, 0xCD, 0xFE,
    0xE2, 0x2D, 0x01, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x18, 0xD9, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x55, 0x00, 0x00, 0x10, 0xED, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xF5, 0x45, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x8C, 0xFF, 0xF9, 0xFF, 0x95, 0x00, 0x02,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x22, 0xE5, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xED, 0x10, 0x00, 0x03, 0x00, 0x9E, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
    0xFF, 0x73, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x2E, 0xE7, 0xFE, 0xFD, 0xFE, 0xF4, 0x52, 0x00, 0x04, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x46, 0xFA, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
    0xFF, 0x9E, 0x00, 0x03, 0x03, 0x00, 0x32, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xA8, 0x05, 0x01,
    0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0x01, 0x96, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xE7, 0x47, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x02, 0x00, 0x86, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x32, 0x00, 0x03,
    0x00, 0x02, 0x00, 0xBE, 0xFE, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0x26, 0x01, 0x02, 0x00, 0x00, 0x00,
    0x00, 0x02, 0x00, 0x23, 0xDD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0xE5, 0x46, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
    0x0B, 0xCB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0xBE, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x40,
    0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x75, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x54,
    0xFD, 0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE9, 0x3E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x53, 0xF4, 0xFD, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x40, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0xB6, 0xFF, 0xFC, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFD, 0xD4, 0x15, 0x01, 0x02, 0x00, 0x00, 0x00, 0x02, 0x00, 0x88, 0xFF, 0xFA, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xDA, 0x1F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x0A, 0xBB, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xB6, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0x2A, 0xFB, 0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x76, 0x00, 0x05, 0x00, 0x00, 0x00, 0x01, 0x02, 0x9B, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFC, 0xFF, 0x8A, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x67, 0xFD, 0xF5, 0xFA, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFE, 0xFC, 0xFB, 0x2A, 0x01, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFE, 0xFE, 0xE5, 0x30, 0x00, 0x03, 0x00, 0x00, 0x01, 0x03, 0x9E, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xDB, 0x1C,
    0x00, 0x02, 0x00, 0x00, 0x03, 0x00, 0x2A, 0xE0, 0xFE, 0xF8, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0x00,
    0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0x04, 0xCC, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
    0xC1, 0x12, 0x01, 0x04, 0x00, 0x01, 0x01, 0x9A, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE7, 0x30, 0x00, 0x03, 0x00, 0x02,
    0x00, 0x12, 0xBA, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xCC, 0x04, 0x03, 0x01, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x26, 0xF4, 0xFD, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xA9, 0x09, 0x00,
    0x05, 0x03, 0x00, 0x7A, 0xFF, 0xFA, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE8, 0x31, 0x00, 0x04, 0x05, 0x00, 0x0A, 0xA1, 0xFF, 0xFC,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFD, 0xF4, 0x26, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x03, 0x00, 0x54, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xA4, 0x13, 0x00, 0x07, 0x02, 0x3D,
    0xF6, 0xF9, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFD, 0xD0, 0x17, 0x03, 0x07, 0x00, 0x19, 0xA7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xFF, 0x54, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
    0x77, 0xFF, 0xFA, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0x38, 0x00, 0x00, 0x0C, 0xAE, 0xFF, 0xFA, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x8B, 0x01, 0x00, 0x00, 0x32, 0xC2, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFA, 0xFF, 0x77, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x8D, 0xFF, 0xFA,
    0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE9, 0x85, 0x28, 0x00, 0x1C, 0xCE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
    0xFF, 0xD1, 0x18, 0x00, 0x1A, 0x7C, 0xE5, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFA, 0xFF, 0x8D, 0x00,
    0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0x00, 0x8D, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE1, 0x95, 0x33, 0x38, 0xCC, 0xFF, 0xFE, 0xFF, 0xFD, 0xFE, 0xCD, 0x39, 0x35, 0x8E,
    0xD4, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xFF, 0x8D, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0x00, 0x78, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFF, 0xFF, 0xF7, 0xCC, 0xDB, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xDB, 0xC9, 0xF3, 0xFF, 0xFF, 0xFE, 0xFD, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0x78, 0x00, 0x03, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x56, 0xF0, 0xFF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFD, 0xFB, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xFF, 0xF0, 0x56, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x2A, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
    0xFF, 0xC7, 0x2A, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x05, 0x80, 0xF8, 0xFF, 0xFD, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFD, 0xFF, 0xF8, 0x80, 0x05, 0x00, 0x03,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x02, 0x00, 0x00, 0x30, 0xB1, 0xFF, 0xFF, 0xFE, 0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xFE, 0xFF, 0xFF, 0xB1, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x04,
    0x00, 0x00, 0x45, 0xBA, 0xFF, 0xFF, 0xFF, 0xFC, 0xFB, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFD, 0xFB, 0xFC, 0xFF, 0xFF, 0xFF, 0xBA, 0x45, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00,
    0x38, 0x9C, 0xE9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFD, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFD, 0xFC, 0xFD, 0xFF, 0xFF, 0xFF,
    0xFF, 0xE9, 0x9C, 0x38, 0x00, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x00, 0x00, 0x12, 0x56,
    0x9F, 0xD8, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xD8, 0x9F, 0x56, 0x12, 0x00, 0x00,
    0x01, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x06, 0x32, 0x64,
    0x95, 0xBE, 0xD8, 0xE8, 0xFD, 0xFF, 0xFF, 0xFD, 0xE8, 0xD8, 0xBE, 0x95, 0x64, 0x32, 0x06, 0x00, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
static inline const lv_image_dsc_t* uiIcon_start_flame() {
    static lv_image_dsc_t d{};
    static bool ok = false;
    if (!ok) {
        d.header.magic = LV_IMAGE_HEADER_MAGIC;
        d.header.cf = LV_COLOR_FORMAT_A8;
        d.header.w = 68; d.header.h = 68; d.header.stride = 68;
        d.data_size = sizeof(ui_ico_start_flame_map);
        d.data = ui_ico_start_flame_map;
        ok = true;
    }
    return &d;
}
// START text (Inter Light 22 px, 2 px letter spacing), ROAST (Inter Light 31 px = 110% of 28 px) and the 17x19 play triangle: pre-drawn at the EXACT final pixel size
// (FreeType, native hinting; the triangle is drawn as vector at 16x then scaled down) -> sharp, not scaled from an old image. Generated by script from Inter-Light.ttf (SIL OFL 1.1).
static const uint8_t ui_ico_start_word_map[77 * 16] = {
    0x00, 0x00, 0x0A, 0x77, 0xCC, 0xF1, 0xF4, 0xD4, 0x84, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xD8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xD4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xB4, 0xFF, 0x76, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0xE4, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE6, 0xAB, 0x36, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xD8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xD4, 0x00, 0x1B, 0xDA, 0xF4, 0x92, 0x63, 0x60, 0x8E, 0xF0, 0xE7, 0x29, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0x50, 0x50,
    0x50, 0x50, 0xD6, 0xD6, 0x50, 0x50, 0x50, 0x50, 0x42, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x16, 0xFB, 0xD3, 0xD5, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE4, 0xC0, 0x50, 0x50, 0x50, 0x59, 0x7D, 0xDD, 0xFB, 0x55, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0x50,
    0x50, 0x50, 0x50, 0xD6, 0xD6, 0x50, 0x50, 0x50, 0x50, 0x42, 0x00, 0xBA, 0xE0, 0x1D, 0x00, 0x00, 0x00, 0x00, 0x1A, 0xDF, 0xD0, 0x01, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF3,
    0x45, 0xFF, 0x34, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE4, 0xA4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC2, 0xF0, 0x10, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x13, 0xFF, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x64, 0xFF, 0x2E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0xCE, 0xA8, 0x02, 0xE8, 0x93, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE4, 0xA4, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x3B, 0xFF, 0x5A, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x28, 0xFF, 0x5E, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x2B, 0xFF, 0x54, 0x00, 0x96, 0xEC, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE4, 0xA4,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x05, 0xEC, 0xCA, 0x11, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8A, 0xF4, 0x0A, 0x00, 0x3E, 0xFF, 0x50, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0xE4, 0xA4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x29, 0xFF, 0x63, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4,
    0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x56, 0xFA, 0xE2, 0x68, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xE4, 0xA3, 0x00, 0x00, 0x01, 0xE1, 0xAF,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE4, 0xA4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x90, 0xFC, 0x23, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xBC, 0xFE, 0xFB, 0xC1, 0x70, 0x14, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x46, 0xFF, 0x48,
    0x00, 0x00, 0x00, 0x86, 0xFA, 0x13, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE4, 0xA9, 0x10, 0x10, 0x10, 0x18, 0x3A, 0x9D, 0xFE, 0x8D, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x6F, 0xB7, 0xFA,
    0xF9, 0x97, 0x0D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0xA4, 0xEA, 0x04, 0x00, 0x00, 0x00, 0x29, 0xFF, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE4, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xEA, 0x72, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x14, 0x80, 0xF7, 0xC5, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0xF4, 0x9D, 0x10, 0x10, 0x10, 0x10, 0x10, 0xD2, 0xCB, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE4,
    0xBB, 0x40, 0x40, 0x40, 0x3F, 0xE5, 0xC8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x59, 0xFF, 0x4F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4,
    0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x2A, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0xE4, 0xA4, 0x00, 0x00, 0x00, 0x00, 0x6A, 0xFF, 0x4E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x17, 0x27, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0A, 0xFF, 0x76, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xBE, 0xDA, 0x40, 0x40, 0x40, 0x40, 0x40, 0x40,
    0x46, 0xF9, 0x89, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE4, 0xA4, 0x00, 0x00, 0x00, 0x00, 0x06, 0xE0, 0xD1, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0x27, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x2C, 0xFF, 0x5D,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1D, 0xFD, 0x7D, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xAF, 0xE5, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE4, 0xA4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0xFF, 0x58,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x24, 0xF9, 0xB8, 0x07, 0x00, 0x00, 0x00,
    0x00, 0x0D, 0xC2, 0xEF, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x7A, 0xFF, 0x22, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x52, 0xFF, 0x46, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE4, 0xA4, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x04, 0xDC, 0xD9, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
    0xFB, 0xE2, 0x84, 0x5C, 0x5B, 0x88, 0xE7, 0xF3, 0x44, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xD7, 0xC5, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xED, 0xA5, 0x00, 0x00, 0x00, 0x00, 0x00,
    0xE4, 0xA4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5D, 0xFF, 0x63, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC4, 0xC4, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x2F, 0xA0, 0xDF, 0xF9, 0xF3, 0xD6, 0x8E, 0x1D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x35, 0xFF, 0x69, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x97, 0xF6,
    0x0E, 0x00, 0x00, 0x00, 0x00, 0xE4, 0xA4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xD6, 0xE1, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0xC4, 0xC4, 0x00, 0x00, 0x00, 0x00, 0x00,
};
static const uint8_t ui_ico_roast_word_map[102 * 22] = {
    0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xEB, 0xC5, 0x81, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x17, 0x75, 0xBD, 0xE8, 0xFA, 0xF4, 0xD8, 0xA1, 0x4A, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x15, 0xFA, 0xFF, 0xDB, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0x5B, 0xAB, 0xDD,
    0xF5, 0xF2, 0xDB, 0xA4, 0x4F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x14, 0x04, 0xFF, 0xFF, 0xE0, 0xDC, 0xDC, 0xDC, 0xDC, 0xE0, 0xF4, 0xFF, 0xFF, 0xF5, 0x5B, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x7C, 0xF5, 0xFF, 0xFF, 0xF6, 0xE1, 0xE8, 0xFF, 0xFF, 0xFF, 0xCD, 0x2F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xFF, 0xFA, 0xFF, 0x3D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x38, 0xD7, 0xFF, 0xFF, 0xF8, 0xE2, 0xE5, 0xFD, 0xFF, 0xFF, 0xC4, 0x22, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xDC, 0xDC, 0xDC, 0xDC, 0xDC,
    0xDC, 0xE3, 0xFF, 0xFD, 0xDC, 0xDC, 0xDC, 0xDC, 0xDC, 0xDC, 0xDC, 0x11, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x31, 0xA8,
    0xFF, 0xFE, 0x4F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x09, 0xB6, 0xFF, 0xFB, 0x98, 0x34, 0x03, 0x00, 0x00, 0x11, 0x5E, 0xD5, 0xFF, 0xF8,
    0x50, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xD0, 0xFF, 0x81, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x37, 0xF3, 0xFF, 0xBA, 0x41, 0x05, 0x00, 0x00, 0x0B, 0x56, 0xD7, 0xFF, 0xE1, 0x1D, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8A, 0xFF, 0xE5, 0x09, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xAA, 0xFF, 0xED, 0x3E, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x06, 0xA2, 0xFF, 0xFA, 0x39, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xFF, 0xCF, 0x0F, 0xF8,
    0xF3, 0x0B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xD2, 0xFF, 0x93, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0A, 0xC0,
    0xFF, 0xAB, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE6, 0xFF, 0x51, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5C, 0xFF, 0xF7,
    0x2B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9E, 0xFF, 0xDC, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x91, 0xFF, 0x76, 0x00, 0xB0, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3A, 0xFF, 0xE7, 0x05, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0xFD, 0xFF, 0x15, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xA1, 0xFF, 0x88, 0x00, 0x00,
    0x00, 0x00, 0x03, 0xE1, 0xFF, 0x76, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE4, 0xFF, 0x6C, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0xEB, 0xFE, 0x1E, 0x00, 0x56, 0xFF, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x62,
    0xFF, 0xB1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x96, 0xB0, 0x2B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x89, 0xFF, 0x9A, 0x00, 0x00, 0x00, 0x00, 0x4D, 0xFF, 0xEC, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x66, 0xFF, 0xD4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x52, 0xFF, 0xC1, 0x00, 0x00, 0x08, 0xEF, 0xFF, 0x23, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x5F, 0xFF, 0xC8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9C, 0xFF, 0x8C, 0x00, 0x00, 0x00, 0x00, 0x99, 0xFF, 0x9B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0D, 0xFB, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xB2, 0xFF, 0x62, 0x00, 0x00, 0x00,
    0x96, 0xFF, 0x83, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0xFE, 0xFF, 0x47, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xE1, 0xFF, 0x5A, 0x00, 0x00, 0x00, 0x00, 0xCD, 0xFF, 0x53, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC9, 0xFF, 0x54, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x16,
    0xFB, 0xF3, 0x0C, 0x00, 0x00, 0x00, 0x33, 0xFF, 0xE2, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x95, 0xFF, 0xF8, 0x75, 0x0A, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xEE, 0x0D, 0x00, 0x00,
    0x00, 0x00, 0xEF, 0xFF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xA3, 0xFF, 0x76, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x72, 0xFF, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCE, 0xFF, 0x45, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x04, 0x98, 0xFF, 0xFF, 0xF3, 0xA0, 0x4C, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x2D, 0x9F,
    0xFF, 0xFF, 0x61, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFD, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x93, 0xFF, 0x85, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xD1, 0xFF, 0x39, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6A, 0xFF, 0xA6, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xB7, 0xFD, 0xFF, 0xFF, 0xFA, 0xBF, 0x6F, 0x15, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xE0, 0xDC, 0xDC,
    0xDC, 0xDC, 0xE0, 0xF3, 0xFF, 0xFF, 0xF6, 0x6A, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFD, 0xFF, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x92, 0xFF, 0x85, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0xFF, 0xD6, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x0F, 0xF6, 0xF7, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x64, 0xAB, 0xEE, 0xFF, 0xFF, 0xF8, 0x96,
    0x12, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFF, 0xB3, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0x37, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xA3, 0xFF, 0x77, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x93, 0xFF,
    0x73, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xA1, 0xFF, 0x69, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x03, 0x44, 0x9D, 0xF9, 0xFF, 0xE5, 0x2A, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x87, 0xFF, 0xDD, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0xCE, 0xFF, 0x53, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC8, 0xFF, 0x55, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x06, 0xEC, 0xFF, 0xEA, 0xE4, 0xE4, 0xE4, 0xE4, 0xE4, 0xE4, 0xE4, 0xEF, 0xFF, 0xCA, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xB4, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xEC, 0xFF,
    0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9A, 0xFF, 0x9B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x0C, 0xFA, 0xFF, 0x21, 0x00, 0x00, 0x00, 0x00, 0x00, 0x53, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x2B,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0xD5, 0xFF, 0x61, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x71, 0xFF, 0xEC, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4E, 0xFF, 0xEC, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0xFF, 0xD6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xB3, 0xFF, 0x5F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x88, 0xFF, 0x8C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x88, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xDF, 0xFF, 0x89, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xE2, 0xFF, 0x77,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xE2, 0xFF, 0x6E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x17, 0xFB, 0xF9, 0x0F,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x2E, 0xFF, 0xE8, 0x04, 0x00, 0x00, 0x00, 0x00, 0xBC, 0xC4, 0x2C, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x94, 0xFF, 0x8C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5C, 0xFF, 0xF7, 0x1E, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x5E, 0xFF, 0xF7, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9C, 0xFF, 0xDE, 0x08, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x74, 0xFF, 0xB1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xD5, 0xFF, 0x4E, 0x00, 0x00, 0x00, 0x00, 0xC8,
    0xFF, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0xDD, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
    0xCF, 0xFF, 0xA3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xAC, 0xFF, 0xED, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x05, 0x9E, 0xFF,
    0xFA, 0x3B, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xD3, 0xFF, 0x59, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFF,
    0xAF, 0x00, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xF5, 0x39, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x9B, 0xFF, 0xE9, 0x0A, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x47, 0xFF, 0xFE, 0x31, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0A, 0xB9, 0xFF, 0xFA, 0x97, 0x34, 0x02, 0x00,
    0x00, 0x10, 0x5C, 0xD2, 0xFF, 0xF9, 0x53, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF6, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x23, 0xFF, 0xFA, 0x15, 0x00, 0x00, 0x00, 0x01, 0xB0, 0xFF, 0xF9, 0x9C, 0x33, 0x05, 0x00, 0x00, 0x0E, 0x55, 0xCD, 0xFF,
    0xFA, 0x48, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xBC, 0xFF, 0xBC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
    0x80, 0xF7, 0xFF, 0xFF, 0xF6, 0xE1, 0xE7, 0xFE, 0xFF, 0xFF, 0xD0, 0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x94, 0xFF, 0xAA, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCA, 0xFF, 0x71, 0x00, 0x00, 0x00, 0x00, 0x05, 0x93, 0xFD, 0xFF, 0xFF, 0xFD,
    0xE5, 0xEB, 0xFD, 0xFF, 0xFF, 0xDC, 0x44, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0xFE, 0xFF, 0x49, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x19, 0x77, 0xBE, 0xEA, 0xFB, 0xF5, 0xDA, 0xA3, 0x4D, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x06, 0xED, 0xFF, 0x53, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xFF, 0xD2, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x29, 0x89, 0xC7, 0xEC, 0xFB, 0xF0, 0xDA, 0xA9, 0x5A, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x34, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
static const uint8_t ui_ico_start_play17_map[17 * 19] = {
    0x14, 0x4D, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xD7, 0xFF, 0xDC, 0x66, 0x04, 0x00, 0x02,
    0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xFF, 0xCD, 0x4E, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0xFD, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0xB6, 0x37, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFD, 0xFD, 0xFF, 0xFD, 0x9C, 0x23, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF2, 0x84,
    0x12, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE2, 0x69, 0x05, 0x00, 0x01, 0x00, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xFF, 0xFF, 0xCE, 0x50, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0xA7, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFA, 0xFB,
    0xFF, 0x26, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xFF, 0xFF, 0xA7, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xFF, 0xFF, 0xD8, 0x5D, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE8,
    0x74, 0x0A, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0xFF, 0xF6, 0x8C, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
    0xFF, 0xFF, 0xFD, 0xFD, 0xFF, 0xFF, 0xA4, 0x28, 0x00, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0xFD, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0xBB, 0x3C, 0x00,
    0x00, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xFF, 0xD0, 0x52, 0x00, 0x00, 0x03, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0xD7, 0xFF, 0xDC, 0x67, 0x05, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x14, 0x4D, 0x11, 0x00, 0x00, 0x03,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
};
static inline const lv_image_dsc_t* uiIcon_start_word() {
    static lv_image_dsc_t d{};
    static bool ok = false;
    if (!ok) {
        d.header.magic = LV_IMAGE_HEADER_MAGIC;
        d.header.cf = LV_COLOR_FORMAT_A8;
        d.header.w = 77; d.header.h = 16; d.header.stride = 77;
        d.data_size = sizeof(ui_ico_start_word_map);
        d.data = ui_ico_start_word_map;
        ok = true;
    }
    return &d;
}
static inline const lv_image_dsc_t* uiIcon_roast_word() {
    static lv_image_dsc_t d{};
    static bool ok = false;
    if (!ok) {
        d.header.magic = LV_IMAGE_HEADER_MAGIC;
        d.header.cf = LV_COLOR_FORMAT_A8;
        d.header.w = 102; d.header.h = 22; d.header.stride = 102;
        d.data_size = sizeof(ui_ico_roast_word_map);
        d.data = ui_ico_roast_word_map;
        ok = true;
    }
    return &d;
}
static inline const lv_image_dsc_t* uiIcon_start_play17() {
    static lv_image_dsc_t d{};
    static bool ok = false;
    if (!ok) {
        d.header.magic = LV_IMAGE_HEADER_MAGIC;
        d.header.cf = LV_COLOR_FORMAT_A8;
        d.header.w = 17; d.header.h = 19; d.header.stride = 17;
        d.data_size = sizeof(ui_ico_start_play17_map);
        d.data = ui_ico_start_play17_map;
        ok = true;
    }
    return &d;
}
static void uiHomeStartCb(lv_event_t *e)   { (void)e; if (g_uiOps.startManual) g_uiOps.startManual(); uiNavGo(UI_PAGE_CONTROL); }
static void uiHomeModeCb(lv_event_t *e)    { (void)e; if (g_uiOps.cycleLinkMode) g_uiOps.cycleLinkMode(); }
static void uiHomeSettingCb(lv_event_t *e) { (void)e; if (!g_uiSnap.batchLive) uiNavGo(UI_PAGE_SETTING); }

static inline void uiBuildHome(lv_obj_t *scr) {
    g_uiMain = UiMainState{};
    // Top bar: upper-case "HOME" + clock / IP rotating every 10 s + 5-level battery
    g_uiMain.shell = uiCreateShell(scr, "HOME");
    uiUpdateTopRight(g_uiMain.shell, g_uiSnap.batPct, g_uiSnap.batCharging);

    // Inner H = 202 px: START button (240 x 108) | 5 px | bottom row (89 px). All three buttons span 240 px: offset by -UI_MARGIN to touch the screen edge
    UiToneBtn btnStart = uiCreateToneBtn(g_uiMain.shell.body, UI_HOME_W, UI_START_H, UI_TONE_RED);
    lv_obj_align(btnStart.btn, LV_ALIGN_TOP_LEFT, -UI_MARGIN, 0);
    lv_obj_add_event_cb(btnStart.btn, uiHomeStartCb, LV_EVENT_CLICKED, nullptr);

    // Round orange-red END-button badge with flame cut-out (A8, same coordinates)
    lv_obj_t *imgBadge = uiCreateIconImg(btnStart.btn, uiIcon_start_flame(), UI_HEX_RED);
    lv_obj_align(imgBadge, LV_ALIGN_LEFT_MID, UI_START_BADGE_X, 0);

    // Style 7: line 1 = START (white, 22 px letter-spaced) + white play triangle 17x19 at the right; line 2 = ROAST (orange, 31 px).
    // All three are pre-drawn A8 images at the exact size (sharp). Both lines are edge-aligned: ROAST and triangle right edge = UI_START_ROAST_R.
    const lv_image_dsc_t *dRoast = uiIcon_roast_word();
    const lv_image_dsc_t *dWord  = uiIcon_start_word();
    const int32_t xLeft = UI_START_ROAST_R - dRoast->header.w;

    lv_obj_t *imgStartWord = uiCreateIconImg(btnStart.btn, dWord, UI_HEX_TEXT);
    lv_obj_set_pos(imgStartWord, xLeft, UI_START_LINE1_BASE - dWord->header.h);

    lv_obj_t *imgPlay = uiCreateIconImg(btnStart.btn, uiIcon_start_play17(), UI_HEX_TEXT);
    lv_obj_set_pos(imgPlay, UI_START_ROAST_R - 17, UI_START_TRI_Y);

    lv_obj_t *imgRoast = uiCreateIconImg(btnStart.btn, dRoast, UI_HEX_RED);
    lv_obj_set_pos(imgRoast, xLeft, UI_START_ROAST_BASE - dRoast->header.h);

    // Bottom row: Mode (117 px, extends left) | 5 px | Setting (118 px, extends right), 89 px high
    g_uiMain.btnMode = uiCreateToneBtn(g_uiMain.shell.body, UI_HOME_COL_L, 89, UI_TONE_SILVER);
    lv_obj_align(g_uiMain.btnMode.btn, LV_ALIGN_BOTTOM_LEFT, -UI_MARGIN, 0);
    lv_obj_add_event_cb(g_uiMain.btnMode.btn, uiHomeModeCb, LV_EVENT_CLICKED, nullptr);

    g_uiMain.imgModeIco = uiCreateIconImg(g_uiMain.btnMode.btn, uiIcon_chip_lg(), UI_HEX_TEXT);
    lv_obj_align(g_uiMain.imgModeIco, LV_ALIGN_TOP_MID, 0, 8);

    g_uiMain.lblModeSub = lv_label_create(g_uiMain.btnMode.btn);
    lv_label_set_text(g_uiMain.lblModeSub, uiTr(STR_STANDALONE));
    lv_obj_set_style_text_font(g_uiMain.lblModeSub, UI_FONT_T5, LV_PART_MAIN);
    lv_obj_set_style_text_color(g_uiMain.lblModeSub, lv_color_hex(UI_HEX_TEXT), LV_PART_MAIN);
    lv_obj_align(g_uiMain.lblModeSub, LV_ALIGN_BOTTOM_MID, 0, -7);

    // Setting: cream gear (body) + small orange center, cream Setting text; same position as the Mode button (icon 8 px from the top, T5 text 7 px from the bottom)
    g_uiMain.btnSetting = uiCreateToneBtn(g_uiMain.shell.body, UI_HOME_COL_R, 89, UI_TONE_SILVER);
    lv_obj_align(g_uiMain.btnSetting.btn, LV_ALIGN_BOTTOM_RIGHT, UI_MARGIN, 0);
    lv_obj_add_event_cb(g_uiMain.btnSetting.btn, uiHomeSettingCb, LV_EVENT_CLICKED, nullptr);
    lv_obj_set_style_border_color(g_uiMain.btnSetting.btn, lv_color_hex(UI_HEX_ORANGE), LV_PART_MAIN | LV_STATE_PRESSED);   // pressed border: logo orange only
    lv_obj_set_style_border_color(g_uiMain.btnMode.btn, lv_color_hex(UI_HEX_ORANGE), LV_PART_MAIN | LV_STATE_PRESSED);

    lv_obj_t *imgGear = uiCreateIconImg(g_uiMain.btnSetting.btn, uiIcon_gear_body(), UI_HEX_TEXT);
    lv_obj_align(imgGear, LV_ALIGN_TOP_MID, 0, 8);
    lv_obj_t *imgHub = uiCreateIconImg(g_uiMain.btnSetting.btn, uiIcon_gear_hub(), UI_HEX_RED);
    lv_obj_align(imgHub, LV_ALIGN_TOP_MID, 0, 8);

    lv_obj_t *lblSet = lv_label_create(g_uiMain.btnSetting.btn);
    lv_label_set_text(lblSet, uiTr(STR_SETTING));
    lv_obj_set_style_text_font(lblSet, UI_FONT_T5, LV_PART_MAIN);
    lv_obj_set_style_text_color(lblSet, lv_color_hex(UI_HEX_TEXT), LV_PART_MAIN);
    lv_obj_align(lblSet, LV_ALIGN_BOTTOM_MID, 0, -7);
}

static inline void uiSyncHome() {
    uiUpdateTopRight(g_uiMain.shell, g_uiSnap.batPct, g_uiSnap.batCharging);

    if (!g_uiMain.lblModeSub || !g_uiMain.imgModeIco) return;

    const bool blinkOn = ((millis() / 500UL) % 2UL) == 0;
    const bool modeChanged = (g_uiMain.lastLinkMode != static_cast<int>(g_uiSnap.linkMode));

    // 0 = HiBean (BLE) | 1 = Artisan (WiFi WS:81) | 2 = Web Portal (HTTP:80) | 3 = Standalone
    // Single-color icon (tinted by tone); status text and tone follow the mode
    // HiBean / Artisan: logo in original colors (not tinted); Web Portal: blue; Standalone: cream
    struct ModeLook { const lv_image_dsc_t *(*icon)(); UiTone tone; uint32_t hex; bool native; };
    static const ModeLook kLook[4] = {
        { uiIcon_hibean,    UI_TONE_AMBER, UI_HEX_TEXT, true  },
        { uiIcon_artisan,   UI_TONE_AMBER, UI_HEX_TEXT, true  },
        { uiIcon_globe_lg,  UI_TONE_CYAN,  UI_HEX_CYAN, false },
        { uiIcon_chip_lg,   UI_TONE_AMBER, UI_HEX_TEXT, false },
    };
    const uint8_t lm = (g_uiSnap.linkMode < 4) ? g_uiSnap.linkMode : 3;
    const ModeLook &lk = kLook[lm];
    const bool linked = (lm == 0) ? g_uiSnap.bleConnected : (lm == 1) ? g_uiSnap.artisanConnected
                      : (lm == 2) ? g_uiSnap.webConnected : true;
    if (modeChanged) {
        lv_image_set_src(g_uiMain.imgModeIco, lk.icon());
        uiSetIconColor(g_uiMain.imgModeIco, lk.hex);
        lv_obj_set_style_image_recolor_opa(g_uiMain.imgModeIco, lk.native ? LV_OPA_TRANSP : LV_OPA_COVER, LV_PART_MAIN);
        lv_obj_align(g_uiMain.imgModeIco, LV_ALIGN_TOP_MID, 0, 8);
        lv_obj_set_style_text_color(g_uiMain.lblModeSub, lv_color_hex(UI_HEX_TEXT), LV_PART_MAIN);   // status text always cream
        uiToneBtnSetTone(g_uiMain.btnMode, lk.tone);
        uiToneBtnSetBar(g_uiMain.btnMode, true, false);
        lv_obj_set_style_border_color(g_uiMain.btnMode.btn, lv_color_hex(UI_HEX_ORANGE), LV_PART_MAIN | LV_STATE_PRESSED);   // pressed border: logo orange only
        // Dummy char so the next comparison always differs -> the center label is redrawn (even cleared to empty when switching to HiBean/Alone without a time)
        g_uiMain.lastTopMid[0] = '\x01'; g_uiMain.lastTopMid[1] = '\0';
    }
    {
        const char *want = lm == 3 ? uiTr(STR_STANDALONE) : (linked ? uiTr(STR_CONNECTED) : uiTr(STR_WAIT_CONN));
        if (strcmp(lv_label_get_text(g_uiMain.lblModeSub), want) != 0) lv_label_set_text(g_uiMain.lblModeSub, want);
    }
    lv_obj_set_style_image_opa(g_uiMain.imgModeIco, linked || blinkOn ? LV_OPA_COVER : LV_OPA_20, LV_PART_MAIN);
    g_uiMain.lastLinkMode = g_uiSnap.linkMode;

    // Middle of the top bar:
    // - Artisan (1) / Web Portal (2): IP address <-> HH:MM clock every 10 s (if time is synced)
    // - HiBean (0) / Standalone (3): HH:MM clock when synced
    if (g_uiMain.shell.lblMid) {
        const bool isNetMode  = (g_uiSnap.linkMode == 1 || g_uiSnap.linkMode == 2);
        const bool showClock  = g_uiSnap.clockSynced && (!isNetMode || (((millis() / 10000UL) % 2UL) == 1));
        const char *wantText  = "";
        uint32_t    wantColor = UI_HEX_TEXT;

        if (showClock) {
            wantText  = g_uiSnap.clockStr;
            wantColor = UI_HEX_TEXT;
        } else if (isNetMode) {
            wantText  = g_uiSnap.ipStr;
            wantColor = UI_HEX_ORANGE;   // IP is always logo orange
        }

        if (strcmp(g_uiMain.lastTopMid, wantText) != 0) {
            snprintf(g_uiMain.lastTopMid, sizeof(g_uiMain.lastTopMid), "%s", wantText);
            lv_obj_set_style_text_color(g_uiMain.shell.lblMid, lv_color_hex(wantColor), LV_PART_MAIN);
            lv_label_set_text(g_uiMain.shell.lblMid, wantText);
            if (wantText[0]) uiShellCenterMid(g_uiMain.shell);
        }
    }
}

static void uiBackHomeCb(lv_event_t *e) { (void)e; uiNavGo(UI_PAGE_HOME); }

// ---------------- SETTING (2x2 grid: WiFi | PID | System | Language, 72+5+72+5+48 = 202 px) ----------------
static void uiSetWifiCb(lv_event_t *e)   { (void)e; uiNavGo(UI_PAGE_WIFI); }
static void uiSetPidCb(lv_event_t *e)    { (void)e; uiNavGo(UI_PAGE_PID); }
static void uiSetSystemCb(lv_event_t *e) { (void)e; uiNavGo(UI_PAGE_SYSTEM); }

static void uiSetLangCycleCb(lv_event_t *e) {
    (void)e;
    UiLang next = uiNextEnabledLang(uiLangGet());
    uiLangSet(next);
    uiNavRequestRebuild();
}

// One-layer A8 icon -> two stacked layers of the same size: the "mask = true" part is tinted hexB, the rest hexA (centered in the parent).
// Buffers come from PSRAM once per icon (no internal RAM); if memory is short the whole icon is drawn in hexA.
typedef bool (*UiIconMaskFn)(int x, int y);
static inline void uiCreateTwoToneIcon(lv_obj_t *parent, const lv_image_dsc_t *src, UiIconMaskFn mask, uint32_t hexA, uint32_t hexB) {
    const int w = src->header.w, h = src->header.h;
    const size_t n = (size_t)w * h;
    struct Cache { const lv_image_dsc_t *key; uint8_t *buf; lv_image_dsc_t dA, dB; };
    static Cache cache[4] = {};
    Cache *c = nullptr;
    for (auto &e : cache) { if (e.key == src) { c = &e; break; } }
    if (!c) {
        for (auto &e : cache) { if (!e.key) { c = &e; break; } }
        if (!c) { lv_obj_t *one = uiCreateIconImg(parent, src, hexA); lv_obj_center(one); return; }
        c->key = src;
        c->buf = static_cast<uint8_t*>(heap_caps_malloc(n * 2, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT));
        if (c->buf) {
            const uint8_t *px = src->data;
            for (int y = 0; y < h; ++y) {
                for (int x = 0; x < w; ++x) {
                    const uint8_t v = px[(size_t)y * w + x];
                    const bool m = mask(x, y);
                    c->buf[(size_t)y * w + x]     = m ? 0 : v;
                    c->buf[n + (size_t)y * w + x] = m ? v : 0;
                }
            }
            c->dA = *src; c->dA.data = c->buf;
            c->dB = *src; c->dB.data = c->buf + n;
        }
    }
    if (!c->buf) { lv_obj_t *one = uiCreateIconImg(parent, src, hexA); lv_obj_center(one); return; }
    lv_obj_t *ia = uiCreateIconImg(parent, &c->dA, hexA); lv_obj_center(ia);
    lv_obj_t *ib = uiCreateIconImg(parent, &c->dB, hexB); lv_obj_center(ib);
}
// Orange regions of each icon (pixel coordinates in the A8 image)
static bool uiPidTextMask(int x, int y)  { return y >= 15 && y <= 28 && x >= 12 && x <= 39; }   // "P-I-D" letters (>= 2 px from the chip body)
static bool uiWifiDotMask(int x, int y)  { (void)x; return y >= 38; }                             // bottom dot (the three wave arcs are at y <= 35)
static bool uiSysKnobMask(int x, int y) {                                                         // three slider knobs (slider lines and gear stay cream)
    return (y <= 8  && x >= 6  && x <= 13) ||
           (y >= 9  && y <= 17 && x >= 22 && x <= 30) ||
           (y >= 19 && y <= 28 && x >= 9  && x <= 17);
}

static inline void uiBuildSetting(lv_obj_t *scr) {
    g_uiMain = UiMainState{};
    g_uiMain.shell = uiCreateShell(scr, uiTr(STR_T_SETTING));
    uiBodyFullWidth(g_uiMain.shell);
    uiUpdateTopRight(g_uiMain.shell, g_uiSnap.batPct, g_uiSnap.batCharging);

    const int32_t tileH = 72;
    const int32_t yRow2 = tileH + UI_GAP;

    // 1. Top-left cell: WiFi
    UiToneBtn bWifi = uiCreateToneBtn(g_uiMain.shell.body, UI_FULL_COL2_W, tileH, UI_TONE_CYAN);
    lv_obj_set_pos(bWifi.btn, 0, 0);
    uiToneBtnSetBar(bWifi, true, false);
    lv_obj_add_event_cb(bWifi.btn, uiSetWifiCb, LV_EVENT_CLICKED, nullptr);
    uiCreateTwoToneIcon(bWifi.btn, uiIcon_wifi_lg(), uiWifiDotMask, UI_HEX_TEXT, UI_HEX_ORANGE);   // three arcs cream, dot orange

    // 2. Top-right cell: PID
    UiToneBtn bPid = uiCreateToneBtn(g_uiMain.shell.body, UI_FULL_COL2_W_R, tileH, UI_TONE_ORANGE);
    lv_obj_set_pos(bPid.btn, UI_FULL_COL2_W + UI_GAP, 0);
    uiToneBtnSetBar(bPid, true, false);
    lv_obj_add_event_cb(bPid.btn, uiSetPidCb, LV_EVENT_CLICKED, nullptr);
    uiCreateTwoToneIcon(bPid.btn, uiIcon_pid_chip(), uiPidTextMask, UI_HEX_TEXT, UI_HEX_ORANGE);   // chip body + pins + small text cream, the "PID" letters orange

    // 3. Bottom-right cell: SYSTEM (Slider logo + gear - adjusts Overheat & IDLE time)
    g_uiMain.btnSystem = uiCreateToneBtn(g_uiMain.shell.body, UI_FULL_COL2_W_R, tileH, UI_TONE_GREEN);
    lv_obj_set_pos(g_uiMain.btnSystem.btn, UI_FULL_COL2_W + UI_GAP, yRow2);
    uiToneBtnSetBar(g_uiMain.btnSystem, true, false);
    lv_obj_add_event_cb(g_uiMain.btnSystem.btn, uiSetSystemCb, LV_EVENT_CLICKED, nullptr);
    uiCreateTwoToneIcon(g_uiMain.btnSystem.btn, uiIcon_system_lg(), uiSysKnobMask, UI_HEX_TEXT, UI_HEX_ORANGE);   // slider lines + gear cream, three knobs orange

    // 4. Bottom-left cell: Language
    g_uiMain.btnLang = uiCreateToneBtn(g_uiMain.shell.body, UI_FULL_COL2_W, tileH, UI_TONE_ORANGE);
    lv_obj_set_pos(g_uiMain.btnLang.btn, 0, yRow2);
    uiToneBtnSetBar(g_uiMain.btnLang, true, false);
    lv_obj_add_event_cb(g_uiMain.btnLang.btn, uiSetLangCycleCb, LV_EVENT_CLICKED, nullptr);

    lv_obj_t *langBox = lv_obj_create(g_uiMain.btnLang.btn);
    lv_obj_remove_style_all(langBox);
    lv_obj_set_size(langBox, 52, 52);
    lv_obj_set_style_radius(langBox, 9, LV_PART_MAIN);
    lv_obj_set_style_bg_color(langBox, lv_color_hex(UI_HEX_ORANGE), LV_PART_MAIN);
    lv_obj_set_style_bg_opa(langBox, LV_OPA_COVER, LV_PART_MAIN);
    lv_obj_remove_flag(langBox, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_remove_flag(langBox, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_center(langBox);

    g_uiMain.lblLangCut = lv_label_create(langBox);
    lv_label_set_text(g_uiMain.lblLangCut, uiLangCode(uiLangGet()));
    lv_obj_set_style_text_font(g_uiMain.lblLangCut, UI_FONT_T2, LV_PART_MAIN);
    lv_obj_set_style_text_color(g_uiMain.lblLangCut, lv_color_hex(UI_HEX_CARD), LV_PART_MAIN);
    lv_obj_align(g_uiMain.lblLangCut, LV_ALIGN_CENTER, -1, 0);
    // 1 px bolder: the second text layer is 1 px to the right (the embedded font has Light only); the two layers are balanced around the cell center
    lv_obj_t *lblLangCut2 = lv_label_create(langBox);
    lv_label_set_text(lblLangCut2, uiLangCode(uiLangGet()));
    lv_obj_set_style_text_font(lblLangCut2, UI_FONT_T2, LV_PART_MAIN);
    lv_obj_set_style_text_color(lblLangCut2, lv_color_hex(UI_HEX_CARD), LV_PART_MAIN);
    lv_obj_align(lblLangCut2, LV_ALIGN_CENTER, 0, 0);

    // 5. BACK bar fixed at the bottom (48 px, UI_FONT_T3, upper case)
    uiCreateBackBtn(g_uiMain.shell.body, 48, uiBackHomeCb, UI_SCR_W);
}

// ---------------- SYSTEM (vertical scroll, 5 rows of 72 px: Overheat, Idle screen, Brightness 5 levels, Temperature unit, Sound + BACK 48 px fixed at the bottom) ----------------
static void uiBackSettingCb(lv_event_t *e) { (void)e; uiNavGo(UI_PAGE_SETTING); }

static inline int uiBlLevelIndex(uint8_t pct) {
    static const uint8_t kBlSteps[5] = {50, 63, 75, 88, 100};
    int bestIdx = 2;
    int bestDiff = 999;
    for (int i = 0; i < 5; ++i) {
        int d = abs(static_cast<int>(pct) - static_cast<int>(kBlSteps[i]));
        if (d < bestDiff) { bestDiff = d; bestIdx = i; }
    }
    return bestIdx;
}

static inline void uiSysUnitPaint(bool useF);   // defined in the Temperature unit card section below
static inline void uiSysSoundPaint();           // defined in the Sound card section below
static inline void uiSystemRefreshLabels() {
    if (g_uiMain.lblSysHot) {
        lv_label_set_text_fmt(g_uiMain.lblSysHot, "%d%s", static_cast<int>(lroundf(uiTempDisp(static_cast<float>(g_uiSnap.overheatC)))), uiTempUnit());
    }
    if (g_uiMain.lblSysIdle) {
        if (g_uiSnap.idleMin == 0) {
            lv_label_set_text(g_uiMain.lblSysIdle, "OFF");
        } else {
            lv_label_set_text_fmt(g_uiMain.lblSysIdle, "%um", static_cast<unsigned>(g_uiSnap.idleMin));
        }
    }
    if (g_uiMain.lblSysBl) {
        int lvIdx = uiBlLevelIndex(g_uiSnap.brightnessPct);
        // show only the level (1..5), not the % value
        lv_label_set_text_fmt(g_uiMain.lblSysBl, "%d", lvIdx + 1);
    }
    // °C / °F selector: the selected cell is lit in silver-purple, the other is off
    uiSysUnitPaint(g_uiSnap.unitF);
    uiSysSoundPaint();
}

// Selected row of the System page (hardware keys: PWR next row, BOOT decrease, PLUS increase)
enum UiSysRowIdx : uint8_t {
    UI_SYS_ROW_HOT = 0,
    UI_SYS_ROW_IDLE,
    UI_SYS_ROW_BL,
    UI_SYS_ROW_UNIT,
    UI_SYS_ROW_SOUND,
    UI_SYS_ROWS
};

static uint8_t   g_uiSysRow = 0;
static lv_obj_t *g_uiSysCards[UI_SYS_ROWS] = {nullptr};
static lv_obj_t *g_uiSysList = nullptr;
static uint32_t  g_uiSysLastStepMs = 0;

// Preview one chirp when volume is adjusted / unmuted (does not interrupt a playing sound, silent when muted)
static inline void uiSysSoundPreview() {
#if CUE_ENABLE
    if (!g_uiSnap.soundMuted && g_alarm_sound == ALARM_SND_OFF) g_alarm_sound = ALARM_SND_WAKE;
#endif
}

static inline void uiSysApplyStep(uint8_t row, int delta) {
    intptr_t d = delta;
    if (row == UI_SYS_ROW_HOT) {
        int next = static_cast<int>(g_uiSnap.overheatC) + delta * 5;
        if (next < 220) next = 220;
        if (next > 260) next = 260;
        g_uiSnap.overheatC = static_cast<uint16_t>(next);
        if (g_uiOps.setOverheatC) g_uiOps.setOverheatC(g_uiSnap.overheatC);
    } else if (row == UI_SYS_ROW_IDLE) {
        static const uint8_t kSteps[6] = {0, 1, 3, 5, 10, 15};
        int idx = 3;
        for (int i = 0; i < 6; ++i) if (kSteps[i] == g_uiSnap.idleMin) { idx = i; break; }
        idx += static_cast<int>(d);
        if (idx < 0) idx = 0;
        if (idx > 5) idx = 5;
        g_uiSnap.idleMin = kSteps[idx];
        if (g_uiOps.setIdleMin) g_uiOps.setIdleMin(g_uiSnap.idleMin);
    } else if (row == UI_SYS_ROW_BL) {
        static const uint8_t kBlSteps[5] = {50, 63, 75, 88, 100};
        int idx = uiBlLevelIndex(g_uiSnap.brightnessPct) + static_cast<int>(d);
        if (idx < 0) idx = 0;
        if (idx > 4) idx = 4;
        g_uiSnap.brightnessPct = kBlSteps[idx];
        if (g_uiOps.setBrightnessPct) g_uiOps.setBrightnessPct(g_uiSnap.brightnessPct);
    } else if (row == UI_SYS_ROW_UNIT) {
        // Temperature unit: "-" = °C, "+" = °F (the core still works in °C, only the display changes)
        if (delta != 0) {
            g_uiSnap.unitF = (delta > 0);
            if (g_uiOps.setTempUnitF) g_uiOps.setTempUnitF(g_uiSnap.unitF);
        }
    } else if (row == UI_SYS_ROW_SOUND) {
        // Master volume: hardware BOOT / PLUS = ±10%; when muted PLUS unmutes, BOOT does nothing
        if (g_uiSnap.soundMuted) {
            if (delta > 0) { g_uiSnap.soundMuted = false; if (g_uiOps.setSoundMuted) g_uiOps.setSoundMuted(false); uiSysSoundPreview(); }
        } else if (delta != 0) {
            int v = static_cast<int>(g_uiSnap.volumePct) + delta * 10;
            if (v < UI_VOL_MIN_PCT) v = UI_VOL_MIN_PCT;
            if (v > 100) v = 100;
            g_uiSnap.volumePct = static_cast<uint8_t>(v);
            if (g_uiOps.setVolumePct) g_uiOps.setVolumePct(g_uiSnap.volumePct, true);
            uiSysSoundPreview();
        }
    }
    uiSystemRefreshLabels();
}

static inline void uiSysRefreshSel() {
    for (int i = 0; i < UI_SYS_ROWS; ++i) {
        if (!g_uiSysCards[i]) continue;
        const bool on = (i == g_uiSysRow);
        // Cards have no colored border: the selected row (hardware keys) gets a 2 px cream border, others a 1 px neutral border
        lv_obj_set_style_border_color(g_uiSysCards[i], lv_color_hex(on ? UI_HEX_TEXT : UI_HEX_BORDER), LV_PART_MAIN);
        lv_obj_set_style_border_width(g_uiSysCards[i], on ? 2 : 1, LV_PART_MAIN);
    }
    if (g_uiSysCards[g_uiSysRow]) lv_obj_scroll_to_view(g_uiSysCards[g_uiSysRow], LV_ANIM_OFF);
}

// +/- buttons: act at once on touch (PRESSED) and repeat while held; double input blocked for 150 ms. Does not depend on "release inside the button" like CLICKED
static void uiSysBtnCb(lv_event_t *e) {
    const lv_event_code_t code = lv_event_get_code(e);
    const uint32_t now = millis();
    if (code == LV_EVENT_PRESSED && (now - g_uiSysLastStepMs) < 150) return;
    g_uiSysLastStepMs = now;
    const intptr_t packed = reinterpret_cast<intptr_t>(lv_event_get_user_data(e));   // row*4 + (delta+1)
    const uint8_t row = static_cast<uint8_t>(packed >> 2);
    const int delta = static_cast<int>(packed & 3) - 1;
    g_uiSysRow = row;
    uiSysApplyStep(row, delta);
    uiSysRefreshSel();
}

// System page hardware keys: nextRow = PWR; delta = BOOT(-1) / PLUS(+1)
static inline void uiSystemHardwareBtn(int delta, bool nextRow) {
    if (nextRow) g_uiSysRow = (g_uiSysRow + 1) % UI_SYS_ROWS;
    else         uiSysApplyStep(g_uiSysRow, delta);
    uiSysRefreshSel();
}

static inline lv_obj_t* uiCreateSysRowCard(lv_obj_t *parent, uint32_t accentHex, UiTone tone,
                                           uint8_t row, const char *title,
                                           lv_obj_t **outTitle, lv_obj_t **outVal) {
    lv_obj_t *card = uiCreateCard(parent, UI_SCR_W, 72);
    lv_obj_set_style_pad_hor(card, 6, LV_PART_MAIN);
    lv_obj_add_flag(card, LV_OBJ_FLAG_SCROLL_CHAIN_VER);

    UiToneBtn bDec = uiCreateToneBtn(card, 52, 54, tone);
    lv_obj_align(bDec.btn, LV_ALIGN_LEFT_MID, 0, 0);
    lv_obj_add_flag(bDec.btn, LV_OBJ_FLAG_SCROLL_CHAIN_VER);
    lv_obj_add_event_cb(bDec.btn, uiSysBtnCb, LV_EVENT_PRESSED, reinterpret_cast<void*>(static_cast<intptr_t>(row * 4 + 0)));
    lv_obj_add_event_cb(bDec.btn, uiSysBtnCb, LV_EVENT_LONG_PRESSED_REPEAT, reinterpret_cast<void*>(static_cast<intptr_t>(row * 4 + 0)));
    uiSolidBtnStyle(bDec.btn, accentHex);   // same style as the +/- buttons of the Heater / Air popup
    lv_obj_t *lm = lv_label_create(bDec.btn);
    lv_label_set_text(lm, LV_SYMBOL_MINUS);
    lv_obj_set_style_text_font(lm, UI_FONT_T2, LV_PART_MAIN);
    lv_obj_set_style_text_color(lm, lv_color_hex(UI_HEX_BG), LV_PART_MAIN);
    lv_obj_center(lm);

    UiToneBtn bInc = uiCreateToneBtn(card, 52, 54, tone);
    lv_obj_align(bInc.btn, LV_ALIGN_RIGHT_MID, 0, 0);
    lv_obj_add_flag(bInc.btn, LV_OBJ_FLAG_SCROLL_CHAIN_VER);
    lv_obj_add_event_cb(bInc.btn, uiSysBtnCb, LV_EVENT_PRESSED, reinterpret_cast<void*>(static_cast<intptr_t>(row * 4 + 2)));
    lv_obj_add_event_cb(bInc.btn, uiSysBtnCb, LV_EVENT_LONG_PRESSED_REPEAT, reinterpret_cast<void*>(static_cast<intptr_t>(row * 4 + 2)));
    uiSolidBtnStyle(bInc.btn, accentHex);
    lv_obj_t *lp = lv_label_create(bInc.btn);
    lv_label_set_text(lp, LV_SYMBOL_PLUS);
    lv_obj_set_style_text_font(lp, UI_FONT_T2, LV_PART_MAIN);
    lv_obj_set_style_text_color(lp, lv_color_hex(UI_HEX_BG), LV_PART_MAIN);
    lv_obj_center(lp);

    lv_obj_t *lTit = lv_label_create(card);
    lv_label_set_text(lTit, title);
    lv_obj_set_style_text_font(lTit, UI_FONT_T5, LV_PART_MAIN);
    lv_obj_set_style_text_color(lTit, lv_color_hex(UI_HEX_TEXT_SUB), LV_PART_MAIN);
    lv_obj_align(lTit, LV_ALIGN_TOP_MID, 0, 7);
    if (outTitle) *outTitle = lTit;

    lv_obj_t *lVal = lv_label_create(card);
    lv_obj_set_style_text_font(lVal, UI_FONT_T2, LV_PART_MAIN);
    lv_obj_set_style_text_color(lVal, lv_color_hex(accentHex), LV_PART_MAIN);
    lv_obj_align(lVal, LV_ALIGN_BOTTOM_MID, 0, -6);
    if (outVal) *outVal = lVal;

    if (row < UI_SYS_ROWS) g_uiSysCards[row] = card;
    return card;
}

// Touch on the °C cell (user data 0) or °F cell (user data 1): selects at once, no +/- needed
static void uiSysUnitCb(lv_event_t *e) {
    const bool useF = reinterpret_cast<intptr_t>(lv_event_get_user_data(e)) != 0;
    g_uiSysRow = UI_SYS_ROW_UNIT;
    uiSysApplyStep(UI_SYS_ROW_UNIT, useF ? 1 : -1);
    uiSysRefreshSel();
}

static lv_obj_t *g_uiSysUnitLbl[2] = {nullptr, nullptr};
static lv_obj_t *g_uiSysUnitLbl2[2] = {nullptr, nullptr};   // second text layer (1 px offset) for a bolder look

// Selected cell: solid silver-purple button, black text; other cell: dark fill, gray text (same solid style as the +/- buttons)
static inline void uiSysUnitPaint(bool useF) {
    UiToneBtn *bt[2] = { &g_uiMain.btnSysUnitC, &g_uiMain.btnSysUnitF };
    for (int i = 0; i < 2; ++i) {
        if (!bt[i]->btn) continue;
        const bool sel = (i == 1) == useF;
        if (sel) {
            uiSolidBtnStyle(bt[i]->btn, UI_HEX_GREEN);
        } else {
            const lv_style_selector_t s2[2] = { LV_PART_MAIN, (lv_style_selector_t)LV_PART_MAIN | LV_STATE_PRESSED };
            for (int k = 0; k < 2; k++) {
                lv_obj_set_style_bg_color(bt[i]->btn, lv_color_hex(k == 0 ? UI_HEX_CARD_PRESS : UI_HEX_CARD), s2[k]);
                lv_obj_set_style_bg_opa(bt[i]->btn, LV_OPA_COVER, s2[k]);
                lv_obj_set_style_border_color(bt[i]->btn, lv_color_hex(UI_HEX_BORDER), s2[k]);
            }
        }
        if (g_uiSysUnitLbl[i])  lv_obj_set_style_text_color(g_uiSysUnitLbl[i],  lv_color_hex(sel ? UI_HEX_BG : UI_HEX_TEXT_SUB), LV_PART_MAIN);
        if (g_uiSysUnitLbl2[i]) lv_obj_set_style_text_color(g_uiSysUnitLbl2[i], lv_color_hex(sel ? UI_HEX_BG : UI_HEX_TEXT_SUB), LV_PART_MAIN);
    }
}

static inline lv_obj_t* uiCreateSysUnitCard(lv_obj_t *parent) {
    lv_obj_t *card = uiCreateCard(parent, UI_SCR_W, 72);
    lv_obj_set_style_pad_hor(card, 6, LV_PART_MAIN);
    lv_obj_add_flag(card, LV_OBJ_FLAG_SCROLL_CHAIN_VER);

    // °C / °F buttons: 54 high (same as +/-), 78 wide (1.5x the 52 px +/- button), at both sides of the card; label in the middle (60 px, wraps if long)
    const int32_t bw = 78, bh = 54;
    lv_obj_t *lTit = lv_label_create(card);
    lv_label_set_text(lTit, uiTr(STR_TEMP_UNIT));
    lv_obj_set_width(lTit, 58);
    lv_label_set_long_mode(lTit, LV_LABEL_LONG_WRAP);
    lv_obj_set_style_text_align(lTit, LV_TEXT_ALIGN_CENTER, LV_PART_MAIN);
    lv_obj_set_style_text_font(lTit, UI_FONT_T5, LV_PART_MAIN);
    lv_obj_set_style_text_color(lTit, lv_color_hex(UI_HEX_TEXT_SUB), LV_PART_MAIN);
    lv_obj_align(lTit, LV_ALIGN_CENTER, 0, 0);

    UiToneBtn *bt[2] = { &g_uiMain.btnSysUnitC, &g_uiMain.btnSysUnitF };
    const char *txt[2] = { "°C", "°F" };
    for (int i = 0; i < 2; ++i) {
        *bt[i] = uiCreateToneBtn(card, bw, bh, UI_TONE_GREEN);
        lv_obj_align(bt[i]->btn, i == 0 ? LV_ALIGN_LEFT_MID : LV_ALIGN_RIGHT_MID, 0, 0);
        lv_obj_add_flag(bt[i]->btn, LV_OBJ_FLAG_SCROLL_CHAIN_VER);
        lv_obj_add_event_cb(bt[i]->btn, uiSysUnitCb, LV_EVENT_CLICKED, reinterpret_cast<void*>(static_cast<intptr_t>(i)));
        lv_obj_t *l = lv_label_create(bt[i]->btn);
        lv_label_set_text(l, txt[i]);
        lv_obj_set_style_text_font(l, UI_FONT_T2, LV_PART_MAIN);
        lv_obj_center(l);
        g_uiSysUnitLbl[i] = l;
        // 1 px bolder: a second text layer 1 px to the right (the embedded font has Light only)
        lv_obj_t *l2 = lv_label_create(bt[i]->btn);
        lv_label_set_text(l2, txt[i]);
        lv_obj_set_style_text_font(l2, UI_FONT_T2, LV_PART_MAIN);
        lv_obj_align(l2, LV_ALIGN_CENTER, 1, 0);
        g_uiSysUnitLbl2[i] = l2;
    }
    uiSysUnitPaint(g_uiSnap.unitF);
    g_uiSysCards[UI_SYS_ROW_UNIT] = card;
    return card;
}

// ---- Sound card (row 5): [speaker = Mute/Unmute] + slider 10..100% + % value. Affects chirps only; safety alarms always sound loud ----
static void uiSysMuteCb(lv_event_t *e) {
    (void)e;
    g_uiSysRow = UI_SYS_ROW_SOUND;
    g_uiSnap.soundMuted = !g_uiSnap.soundMuted;
    if (g_uiOps.setSoundMuted) g_uiOps.setSoundMuted(g_uiSnap.soundMuted);
    uiSystemRefreshLabels();
    uiSysRefreshSel();
    uiSysSoundPreview();
}

static void uiSysVolSliderCb(lv_event_t *e) {
    lv_obj_t *s = static_cast<lv_obj_t*>(lv_event_get_target(e));
    const bool released = (lv_event_get_code(e) == LV_EVENT_RELEASED);
    const int v = lv_slider_get_value(s);
    g_uiSysRow = UI_SYS_ROW_SOUND;
    g_uiSnap.volumePct = static_cast<uint8_t>(v);
    if (g_uiSnap.soundMuted) { g_uiSnap.soundMuted = false; if (g_uiOps.setSoundMuted) g_uiOps.setSoundMuted(false); }   // dragging the slider = unmute
    if (g_uiOps.setVolumePct) g_uiOps.setVolumePct(g_uiSnap.volumePct, released);   // while dragging: change takes effect at once; NVS is saved on release
    uiSystemRefreshLabels();
    uiSysRefreshSel();
    if (released) uiSysSoundPreview();
}

// Sound on: solid cream speaker button, cream slider. Muted: dark button, speaker + slider + number turn gray.
static inline void uiSysSoundPaint() {
    const bool muted = g_uiSnap.soundMuted;
    const uint32_t fg = muted ? UI_HEX_TEXT_SUB : UI_HEX_ORANGE;
    if (g_uiMain.btnSysMute.btn) {
        if (!muted) {
            uiSolidBtnStyle(g_uiMain.btnSysMute.btn, UI_HEX_ORANGE);
        } else {
            const lv_style_selector_t s2[2] = { LV_PART_MAIN, (lv_style_selector_t)LV_PART_MAIN | LV_STATE_PRESSED };
            for (int k = 0; k < 2; k++) {
                lv_obj_set_style_bg_color(g_uiMain.btnSysMute.btn, lv_color_hex(k == 0 ? UI_HEX_CARD_PRESS : UI_HEX_CARD), s2[k]);
                lv_obj_set_style_bg_opa(g_uiMain.btnSysMute.btn, LV_OPA_COVER, s2[k]);
                lv_obj_set_style_border_color(g_uiMain.btnSysMute.btn, lv_color_hex(UI_HEX_BORDER), s2[k]);
            }
        }
    }
    if (g_uiMain.lblSysMute) {
        lv_label_set_text(g_uiMain.lblSysMute, muted ? LV_SYMBOL_MUTE : LV_SYMBOL_VOLUME_MAX);
        lv_obj_set_style_text_color(g_uiMain.lblSysMute, lv_color_hex(muted ? UI_HEX_TEXT_SUB : UI_HEX_BG), LV_PART_MAIN);
    }
    if (g_uiMain.sldSysVol) {
        if (lv_slider_get_value(g_uiMain.sldSysVol) != static_cast<int>(g_uiSnap.volumePct))
            lv_slider_set_value(g_uiMain.sldSysVol, g_uiSnap.volumePct, LV_ANIM_OFF);
        lv_obj_set_style_bg_color(g_uiMain.sldSysVol, lv_color_hex(fg), LV_PART_INDICATOR);
        lv_obj_set_style_bg_color(g_uiMain.sldSysVol, lv_color_hex(fg), LV_PART_KNOB);
    }
    if (g_uiMain.lblSysVol) {
        lv_label_set_text_fmt(g_uiMain.lblSysVol, "%u%%", static_cast<unsigned>(g_uiSnap.volumePct));
        lv_obj_set_style_text_color(g_uiMain.lblSysVol, lv_color_hex(fg), LV_PART_MAIN);
    }
}

static inline lv_obj_t* uiCreateSysSoundCard(lv_obj_t *parent) {
    lv_obj_t *card = uiCreateCard(parent, UI_SCR_W, 72);
    lv_obj_set_style_pad_hor(card, 6, LV_PART_MAIN);
    lv_obj_add_flag(card, LV_OBJ_FLAG_SCROLL_CHAIN_VER);

    // Speaker button on the left (52x54 like the +/- buttons)
    g_uiMain.btnSysMute = uiCreateToneBtn(card, 52, 54, UI_TONE_ORANGE);
    lv_obj_align(g_uiMain.btnSysMute.btn, LV_ALIGN_LEFT_MID, 0, 0);
    lv_obj_add_flag(g_uiMain.btnSysMute.btn, LV_OBJ_FLAG_SCROLL_CHAIN_VER);
    lv_obj_add_event_cb(g_uiMain.btnSysMute.btn, uiSysMuteCb, LV_EVENT_CLICKED, nullptr);
    g_uiMain.lblSysMute = lv_label_create(g_uiMain.btnSysMute.btn);
    lv_label_set_text(g_uiMain.lblSysMute, LV_SYMBOL_VOLUME_MAX);
    lv_obj_set_style_text_font(g_uiMain.lblSysMute, UI_FONT_T2, LV_PART_MAIN);
    lv_obj_center(g_uiMain.lblSysMute);

    // VOLUME label (left) + % value (right) on the top line; slider on the bottom line
    lv_obj_t *lTit = lv_label_create(card);
    lv_label_set_text(lTit, uiTr(STR_VOLUME));
    lv_obj_set_style_text_font(lTit, UI_FONT_T5, LV_PART_MAIN);
    lv_obj_set_style_text_color(lTit, lv_color_hex(UI_HEX_TEXT_SUB), LV_PART_MAIN);
    lv_obj_align(lTit, LV_ALIGN_TOP_LEFT, 62, 5);

    g_uiMain.lblSysVol = lv_label_create(card);
    lv_obj_set_style_text_font(g_uiMain.lblSysVol, UI_FONT_T3, LV_PART_MAIN);
    lv_obj_align(g_uiMain.lblSysVol, LV_ALIGN_TOP_RIGHT, -2, 2);

    lv_obj_t *s = lv_slider_create(card);
    g_uiMain.sldSysVol = s;
    lv_obj_set_size(s, 144, 8);
    lv_obj_align(s, LV_ALIGN_BOTTOM_RIGHT, -8, -14);
    lv_slider_set_range(s, UI_VOL_MIN_PCT, 100);
    lv_slider_set_value(s, g_uiSnap.volumePct, LV_ANIM_OFF);
    lv_obj_set_ext_click_area(s, 14);
    lv_obj_set_style_radius(s, LV_RADIUS_CIRCLE, LV_PART_MAIN);
    lv_obj_set_style_bg_color(s, lv_color_hex(UI_HEX_BORDER), LV_PART_MAIN);
    lv_obj_set_style_bg_opa(s, LV_OPA_COVER, LV_PART_MAIN);
    lv_obj_set_style_radius(s, LV_RADIUS_CIRCLE, LV_PART_INDICATOR);
    lv_obj_set_style_bg_opa(s, LV_OPA_COVER, LV_PART_INDICATOR);
    lv_obj_set_style_radius(s, LV_RADIUS_CIRCLE, LV_PART_KNOB);
    lv_obj_set_style_bg_opa(s, LV_OPA_COVER, LV_PART_KNOB);
    lv_obj_set_style_pad_all(s, 6, LV_PART_KNOB);
    lv_obj_add_event_cb(s, uiSysVolSliderCb, LV_EVENT_VALUE_CHANGED, nullptr);
    lv_obj_add_event_cb(s, uiSysVolSliderCb, LV_EVENT_RELEASED, nullptr);

    uiSysSoundPaint();
    g_uiSysCards[UI_SYS_ROW_SOUND] = card;
    return card;
}

static inline void uiBuildSystem(lv_obj_t *scr) {
    g_uiMain = UiMainState{};
    g_uiMain.shell = uiCreateShell(scr, uiTr(STR_SYSTEM));
    uiBodyFullWidth(g_uiMain.shell);
    g_uiSysRow = 0;
    for (int i = 0; i < UI_SYS_ROWS; ++i) g_uiSysCards[i] = nullptr;
    uiUpdateTopRight(g_uiMain.shell, g_uiSnap.batPct, g_uiSnap.batCharging);

    // Vertical scroll frame 230x149 px (shows exactly 2 rows 72+5+72 = 149 px; swipe to rows 3-4: Brightness, Temperature unit)
    lv_obj_t *list = lv_obj_create(g_uiMain.shell.body);
    lv_obj_remove_style_all(list);
    lv_obj_set_size(list, UI_SCR_W, 149);
    lv_obj_align(list, LV_ALIGN_TOP_MID, 0, 0);
    lv_obj_set_flex_flow(list, LV_FLEX_FLOW_COLUMN);
    lv_obj_set_style_pad_row(list, UI_GAP, LV_PART_MAIN);
    lv_obj_set_scroll_dir(list, LV_DIR_VER);
    lv_obj_set_scrollbar_mode(list, LV_SCROLLBAR_MODE_AUTO);
    lv_obj_remove_flag(list, LV_OBJ_FLAG_SCROLL_ELASTIC);
    g_uiSysList = list;

    // Row 1: Overheat level (72 px)
    uiCreateSysRowCard(list, UI_HEX_ORANGE, UI_TONE_ORANGE, 0,
                       uiTr(STR_OVERHEAT), nullptr, &g_uiMain.lblSysHot);

    // Row 2: IDLE time before the Logo page (72 px)
    uiCreateSysRowCard(list, UI_HEX_GREEN, UI_TONE_GREEN, 1,
                       uiTr(STR_IDLE_TIME), nullptr, &g_uiMain.lblSysIdle);

    // Row 3: Screen brightness, 5 levels (shows 1..5, real values 50/63/75/88/100%) (72 px)
    uiCreateSysRowCard(list, UI_HEX_ORANGE, UI_TONE_ORANGE, 2,
                       uiTr(STR_BRIGHTNESS), &g_uiMain.lblSysBlTit, &g_uiMain.lblSysBl);

    // Row 4: Temperature unit - two selector cells °C | °F (72 px), touch a cell directly to select
    uiCreateSysUnitCard(list);

    // Row 5: Sound - speaker (Mute) + volume slider 10..100% + % value (72 px)
    uiCreateSysSoundCard(list);


    uiSystemRefreshLabels();
    uiSysRefreshSel();

    // Fixed at the bottom edge: BACK (48 px)
    uiCreateBackBtn(g_uiMain.shell.body, 48, uiBackSettingCb, UI_SCR_W);
}

// ---------------- WIFI (all upper case, IP T4/T2, AP/WIFI T2, 72+5+72+5+48 = 202 px) ----------------
static void uiWifiSwitchCb(lv_event_t *e) {
    lv_obj_t *sw = static_cast<lv_obj_t*>(lv_event_get_target(e));
    bool staMode = lv_obj_has_state(sw, LV_STATE_CHECKED); // left = AP (false), right = WiFi STA (true)
    if (g_uiOps.setWifiApMode) g_uiOps.setWifiApMode(!staMode);
    uiNavRequestRebuild();
}

static inline void uiBuildWifi(lv_obj_t *scr) {
    g_uiMain = UiMainState{};
    g_uiMain.shell = uiCreateShell(scr, uiTr(STR_WIFI));
    uiBodyFullWidth(g_uiMain.shell);
    uiUpdateTopRight(g_uiMain.shell, g_uiSnap.batPct, g_uiSnap.batCharging);

    lv_obj_t *ipCard = uiCreateCard(g_uiMain.shell.body, UI_SCR_W, 72);
    lv_obj_set_pos(ipCard, 0, 0);
    lv_obj_set_style_border_width(ipCard, 0, LV_PART_MAIN);   // IP card border removed

    lv_obj_t *lt = lv_label_create(ipCard);
    lv_label_set_text(lt, uiTr(STR_IP_ADDRESS));
    lv_obj_set_style_text_font(lt, UI_FONT_T4, LV_PART_MAIN);
    lv_obj_set_style_text_color(lt, lv_color_hex(UI_HEX_TEXT_SUB), LV_PART_MAIN);
    lv_obj_align(lt, LV_ALIGN_TOP_MID, 0, 7);

    g_uiMain.lblIpBig = lv_label_create(ipCard);
    lv_label_set_text(g_uiMain.lblIpBig, g_uiSnap.ipStr);
    lv_obj_set_style_text_font(g_uiMain.lblIpBig, UI_FONT_T2, LV_PART_MAIN);
    lv_obj_set_style_text_color(g_uiMain.lblIpBig, lv_color_hex(UI_HEX_ORANGE), LV_PART_MAIN);
    lv_obj_align(g_uiMain.lblIpBig, LV_ALIGN_BOTTOM_MID, 0, -6);

    lv_obj_t *modeCard = uiCreateCard(g_uiMain.shell.body, UI_SCR_W, 72);
    lv_obj_set_pos(modeCard, 0, 72 + UI_GAP);

    const bool isSta = !g_uiSnap.wifiApMode;

    g_uiMain.lblAp = lv_label_create(modeCard);
    lv_label_set_text(g_uiMain.lblAp, "AP");
    lv_obj_set_style_text_font(g_uiMain.lblAp, UI_FONT_T2, LV_PART_MAIN);
    lv_obj_set_style_text_color(g_uiMain.lblAp,
        lv_color_hex(!isSta ? UI_HEX_TEXT : UI_HEX_TEXT_MUTED), LV_PART_MAIN);   // selected: cream color
    lv_obj_align(g_uiMain.lblAp, LV_ALIGN_LEFT_MID, 18, 0);
    lv_obj_t *lblAp2 = lv_label_create(modeCard);   // second text layer 1 px to the right -> 1 px bolder
    lv_label_set_text(lblAp2, "AP");
    lv_obj_set_style_text_font(lblAp2, UI_FONT_T2, LV_PART_MAIN);
    lv_obj_set_style_text_color(lblAp2, lv_color_hex(!isSta ? UI_HEX_TEXT : UI_HEX_TEXT_MUTED), LV_PART_MAIN);
    lv_obj_align(lblAp2, LV_ALIGN_LEFT_MID, 19, 0);

    g_uiMain.swWifiMode = uiCreateIosSwitch(modeCard, UI_TONE_CYAN);
    lv_obj_set_size(g_uiMain.swWifiMode, 64, 34);
    // Toggle background is always orange (both states: background + the indicator when switched to WIFI)
    lv_obj_set_style_bg_color(g_uiMain.swWifiMode, lv_color_hex(UI_HEX_ORANGE), LV_PART_MAIN);
    lv_obj_set_style_bg_color(g_uiMain.swWifiMode, lv_color_hex(UI_HEX_ORANGE), LV_PART_INDICATOR);
    lv_obj_set_style_bg_color(g_uiMain.swWifiMode, lv_color_hex(UI_HEX_ORANGE), (lv_style_selector_t)LV_PART_INDICATOR | LV_STATE_CHECKED);
    lv_obj_align(g_uiMain.swWifiMode, LV_ALIGN_CENTER, -4, 0);
    if (isSta) lv_obj_add_state(g_uiMain.swWifiMode, LV_STATE_CHECKED);
    lv_obj_add_event_cb(g_uiMain.swWifiMode, uiWifiSwitchCb, LV_EVENT_VALUE_CHANGED, nullptr);

    g_uiMain.lblSta = lv_label_create(modeCard);
    lv_label_set_text(g_uiMain.lblSta, "WIFI");
    lv_obj_set_style_text_font(g_uiMain.lblSta, UI_FONT_T2, LV_PART_MAIN);
    lv_obj_set_style_text_color(g_uiMain.lblSta,
        lv_color_hex(isSta ? UI_HEX_TEXT : UI_HEX_TEXT_MUTED), LV_PART_MAIN);
    lv_obj_align(g_uiMain.lblSta, LV_ALIGN_RIGHT_MID, -12, 0);
    lv_obj_t *lblSta2 = lv_label_create(modeCard);
    lv_label_set_text(lblSta2, "WIFI");
    lv_obj_set_style_text_font(lblSta2, UI_FONT_T2, LV_PART_MAIN);
    lv_obj_set_style_text_color(lblSta2, lv_color_hex(isSta ? UI_HEX_TEXT : UI_HEX_TEXT_MUTED), LV_PART_MAIN);
    lv_obj_align(lblSta2, LV_ALIGN_RIGHT_MID, -11, 0);

    uiCreateBackBtn(g_uiMain.shell.body, 48, uiBackSettingCb, UI_SCR_W);
}

// ---------------- PID SETTINGS (Single editable Kp | Ki | Kd + P-Mode + Cancel / Default / Save) ----------------
static inline void uiPidRefreshCols() {
    float vals[3] = {g_uiMain.editP.kp, g_uiMain.editP.ki, g_uiMain.editP.kd};
    for (int i = 0; i < 3; ++i) {
        if (!g_uiMain.colCard[i] || !g_uiMain.colVal[i]) continue;
        bool active = (i == g_uiMain.activeCol);
        lv_obj_set_style_bg_color(g_uiMain.colCard[i],
            lv_color_hex(active ? UI_HEX_TINT_ORANGE : UI_HEX_CARD), LV_PART_MAIN);
        lv_obj_set_style_border_color(g_uiMain.colCard[i],
            lv_color_hex(active ? UI_HEX_ORANGE : UI_HEX_BORDER), LV_PART_MAIN);
        lv_obj_set_style_border_width(g_uiMain.colCard[i], active ? 2 : 1, LV_PART_MAIN);
        int v100 = static_cast<int>(vals[i] * 100.0f + 0.5f);
        if (i == 1) {                                   // Ki: 2 decimals
            lv_label_set_text_fmt(g_uiMain.colVal[i], "%d.%02d", v100 / 100, v100 % 100);
        } else {
            int v10 = static_cast<int>(vals[i] * 10.0f + 0.5f);
            lv_label_set_text_fmt(g_uiMain.colVal[i], "%d.%d", v10 / 10, v10 % 10);
        }
    }
    if (g_uiMain.pmCard && g_uiMain.pmVal) {
        bool active = (g_uiMain.activeCol == 3);
        bool isM    = (g_uiMain.editP.pm != 0);
        lv_obj_set_style_bg_color(g_uiMain.pmCard,
            lv_color_hex(active ? (isM ? UI_HEX_TINT_CYAN : UI_HEX_TINT_ORANGE) : UI_HEX_CARD), LV_PART_MAIN);
        lv_obj_set_style_border_color(g_uiMain.pmCard,
            lv_color_hex(active ? (isM ? UI_HEX_CYAN : UI_HEX_ORANGE) : UI_HEX_BORDER), LV_PART_MAIN);
        lv_obj_set_style_border_width(g_uiMain.pmCard, active ? 2 : 1, LV_PART_MAIN);
        lv_label_set_text(g_uiMain.pmVal, isM ? "P_ON_M" : "P_ON_E");
        lv_obj_set_style_text_color(g_uiMain.pmVal,
            lv_color_hex(isM ? UI_HEX_CYAN : UI_HEX_ORANGE), LV_PART_MAIN);
    }
}

static void uiPidColClickCb(lv_event_t *e) {
    g_uiMain.activeCol = static_cast<uint8_t>(reinterpret_cast<uintptr_t>(lv_event_get_user_data(e)));
    uiPidRefreshCols();
}

static void uiPidPmClickCb(lv_event_t *e) {
    (void)e;
    g_uiMain.activeCol = 3;
    g_uiMain.editP.pm  = g_uiMain.editP.pm ? 0 : 1;
    uiPidRefreshCols();
}

static void uiPidDefaultCb(lv_event_t *e) {
    (void)e;
    if (g_uiOps.resetPidParams) g_uiOps.resetPidParams(g_uiMain.editP);
    uiPidRefreshCols();
}

static void uiPidSaveCb(lv_event_t *e) {
    (void)e;
    if (g_uiOps.savePidParams) g_uiOps.savePidParams(g_uiMain.editP);
    uiNavGo(UI_PAGE_SETTING);
}

static inline void uiPidHardwareBtn(int delta, bool nextCol) {
    if (nextCol) {
        g_uiMain.activeCol = (g_uiMain.activeCol + 1) % 4;
    } else if (g_uiMain.activeCol == 3) {
        g_uiMain.editP.pm = g_uiMain.editP.pm ? 0 : 1;
    } else if (g_uiMain.activeCol == 0) {
        g_uiMain.editP.kp = constrain(g_uiMain.editP.kp + delta * 0.50f, 0.0f, 50.0f);
    } else if (g_uiMain.activeCol == 1) {
        g_uiMain.editP.ki = constrain(g_uiMain.editP.ki + delta * 0.05f, 0.0f, 2.0f);
    } else {
        g_uiMain.editP.kd = constrain(g_uiMain.editP.kd + delta * 0.50f, 0.0f, 100.0f);
    }
    uiPidRefreshCols();
}

static inline void uiBuildPid(lv_obj_t *scr) {
    g_uiMain = UiMainState{};
    g_uiMain.shell = uiCreateShell(scr, "PID");
    uiBodyFullWidth(g_uiMain.shell);
    uiUpdateTopRight(g_uiMain.shell, g_uiSnap.batPct, g_uiSnap.batCharging);

    if (g_uiOps.readPidParams) g_uiOps.readPidParams(g_uiMain.editP);

    const char *names[3] = {"Kp", "Ki", "Kd"};
    const int32_t w1 = UI_FULL_COL3_W;
    const int32_t w2 = UI_FULL_COL3_W_M;
    const int32_t w3 = UI_FULL_COL3_W_R;
    for (int i = 0; i < 3; ++i) {
        int32_t x = (i == 0) ? 0 : (i == 1 ? w1 + UI_GAP : w1 + UI_GAP + w2 + UI_GAP);
        int32_t w = (i == 1) ? w2 : (i == 2 ? w3 : w1);
        lv_obj_t *c = uiCreateCard(g_uiMain.shell.body, w, 88);
        lv_obj_set_pos(c, x, 0);
        lv_obj_add_flag(c, LV_OBJ_FLAG_CLICKABLE);
        lv_obj_add_event_cb(c, uiPidColClickCb, LV_EVENT_CLICKED,
                            reinterpret_cast<void*>(static_cast<uintptr_t>(i)));
        g_uiMain.colCard[i] = c;

        lv_obj_t *ln = lv_label_create(c);
        lv_label_set_text(ln, names[i]);
        lv_obj_set_style_text_font(ln, UI_FONT_T3, LV_PART_MAIN);
        lv_obj_set_style_text_color(ln, lv_color_hex(UI_HEX_ORANGE), LV_PART_MAIN);
        lv_obj_align(ln, LV_ALIGN_TOP_MID, 0, 8);

        g_uiMain.colVal[i] = lv_label_create(c);
        lv_obj_set_style_text_font(g_uiMain.colVal[i], UI_FONT_T2, LV_PART_MAIN);
        lv_obj_set_style_text_color(g_uiMain.colVal[i], lv_color_hex(UI_HEX_TEXT), LV_PART_MAIN);
        lv_obj_align(g_uiMain.colVal[i], LV_ALIGN_BOTTOM_MID, 0, -12);
    }

    // P-Mode selector (P_ON_E / P_ON_M)
    g_uiMain.pmCard = uiCreateCard(g_uiMain.shell.body, UI_SCR_W, 52);
    lv_obj_set_pos(g_uiMain.pmCard, 0, 88 + UI_GAP);
    lv_obj_add_flag(g_uiMain.pmCard, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_add_event_cb(g_uiMain.pmCard, uiPidPmClickCb, LV_EVENT_CLICKED, nullptr);

    lv_obj_t *lPm = lv_label_create(g_uiMain.pmCard);
    lv_label_set_text(lPm, "P-MODE");
    lv_obj_set_style_text_font(lPm, UI_FONT_T4, LV_PART_MAIN);
    lv_obj_set_style_text_color(lPm, lv_color_hex(UI_HEX_TEXT_SUB), LV_PART_MAIN);
    lv_obj_align(lPm, LV_ALIGN_LEFT_MID, 12, 0);

    g_uiMain.pmVal = lv_label_create(g_uiMain.pmCard);
    lv_obj_set_style_text_font(g_uiMain.pmVal, UI_FONT_T3, LV_PART_MAIN);
    lv_obj_align(g_uiMain.pmVal, LV_ALIGN_RIGHT_MID, -12, 0);

    uiPidRefreshCols();

    // Bottom bar: Cancel | Default | Save
    UiToneBtn btnCancel = uiCreateToneBtn(g_uiMain.shell.body, w1, 52, UI_TONE_SILVER);
    lv_obj_align(btnCancel.btn, LV_ALIGN_BOTTOM_LEFT, 0, 0);
    lv_obj_add_event_cb(btnCancel.btn, uiBackSettingCb, LV_EVENT_CLICKED, nullptr);
    lv_obj_t *lc = lv_label_create(btnCancel.btn);
    lv_label_set_text(lc, uiTr(STR_CANCEL));
    lv_obj_set_style_text_font(lc, UI_FONT_T4, LV_PART_MAIN);
    lv_obj_set_style_text_color(lc, lv_color_hex(UI_HEX_TEXT_SUB), LV_PART_MAIN);
    lv_obj_center(lc);

    UiToneBtn btnDef = uiCreateToneBtn(g_uiMain.shell.body, w2, 52, UI_TONE_ORANGE);
    lv_obj_align(btnDef.btn, LV_ALIGN_BOTTOM_LEFT, w1 + UI_GAP, 0);
    lv_obj_add_event_cb(btnDef.btn, uiPidDefaultCb, LV_EVENT_CLICKED, nullptr);
    lv_obj_t *ld = lv_label_create(btnDef.btn);
    lv_label_set_text(ld, uiTr(STR_DEFAULT));
    lv_obj_set_style_text_font(ld, UI_FONT_T4, LV_PART_MAIN);
    lv_obj_set_style_text_color(ld, lv_color_hex(UI_HEX_ORANGE), LV_PART_MAIN);
    lv_obj_center(ld);

    UiToneBtn btnSave = uiCreateToneBtn(g_uiMain.shell.body, w3, 52, UI_TONE_GREEN);
    lv_obj_align(btnSave.btn, LV_ALIGN_BOTTOM_RIGHT, 0, 0);
    uiToneBtnSetOn(btnSave, true);
    lv_obj_add_event_cb(btnSave.btn, uiPidSaveCb, LV_EVENT_CLICKED, nullptr);
    lv_obj_t *ls = lv_label_create(btnSave.btn);
    lv_label_set_text(ls, uiTr(STR_SAVE));
    lv_obj_set_style_text_font(ls, UI_FONT_T4, LV_PART_MAIN);
    lv_obj_set_style_text_color(ls, lv_color_hex(UI_HEX_TEXT), LV_PART_MAIN);
    lv_obj_center(ls);
}
